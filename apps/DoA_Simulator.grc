<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>DoA_FM</value></param>
<param><key>author</key><value>DoHaiSon</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Direction of Arrival</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>angle</value></param>
<param><key>value</key><value>95.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>label</key><value>Goc Den:</value></param>
<param><key>min_len</key><value>181</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>step</key><value>1.0</value></param>
<param><key>stop</key><value>180.0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>argmax</value></param>
<param><key>block_id</key><value>blocks_probe_signal_x_0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>choose</value></param>
<param><key>value</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0, 1,1</value></param>
<param><key>label0</key><value>Sync</value></param>
<param><key>label1</key><value>DOA</value></param>
<param><key>label</key><value>State: </value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>False</value></param>
<param><key>option1</key><value>True</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>delay</value></param>
<param><key>block_id</key><value>my_block_0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>delay_0</value></param>
<param><key>block_id</key><value>delay_sample</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_item</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pi</value></param>
<param><key>value</key><value>3.14159265</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>taps_up</value></param>
<param><key>cutoff_freq</key><value>7500</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>delay * 180 / pi</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>label</key><value>Phase OFfset: </value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_1</value></param>
<param><key>value</key><value>argmax</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>label</key><value>DOA</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_1_0</value></param>
<param><key>value</key><value>variance</value></param>
<param><key>gui_hint</key><value>tab@0:4,0,1,1</value></param>
<param><key>label</key><value>Angle Variance</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_2</value></param>
<param><key>value</key><value>delay_0</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>label</key><value>Delay Sample: </value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>variance</value></param>
<param><key>block_id</key><value>probe65</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>20</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vol</value></param>
<param><key>value</key><value>0.2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.05</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>DoA_BladeRF_DOApy</key>
<param><key>id</key><value>DoA_BladeRF_DOApy_0</value></param>
<param><key>algorithm</key><value>True</value></param>
<param><key>k</key><value>0.5</value></param>
<param><key>gain</key><value>30</value></param>
<param><key>num_in</key><value>2</value></param>
<param><key>veclen</key><value>1024</value></param>
</block>
<block>
<key>DoA_BladeRF_Delay</key>
<param><key>id</key><value>DoA_BladeRF_Delay_0</value></param>
<param><key>delay</key><value>(delay_0&lt;0)*-delay_0</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>DoA_BladeRF_Delay</key>
<param><key>id</key><value>DoA_BladeRF_Delay_1</value></param>
<param><key>delay</key><value>(delay_0 &gt; 0 ) * delay_0</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>DoA_BladeRF_Hold</key>
<param><key>id</key><value>DoA_BladeRF_Hold_0</value></param>
<param><key>hold</key><value>choose</value></param>
</block>
<block>
<key>DoA_BladeRF_PCA</key>
<param><key>id</key><value>DoA_BladeRF_PCA_0</value></param>
<param><key>vector_size</key><value>10</value></param>
</block>
<block>
<key>DoA_BladeRF_mess_sink_f</key>
<param><key>id</key><value>DoA_BladeRF_mess_sink_f_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>DoA_BladeRF_mess_sink_f</key>
<param><key>id</key><value>DoA_BladeRF_mess_sink_f_1</value></param>
</block>
<block>
<key>DoA_BladeRF_multi_exp</key>
<param><key>id</key><value>DoA_BladeRF_multi_exp_0</value></param>
<param><key>arg</key><value>45*pi/180</value></param>
</block>
<block>
<key>DoA_BladeRF_multi_exp</key>
<param><key>id</key><value>DoA_BladeRF_multi_exp_1</value></param>
<param><key>arg</key><value>0.0</value></param>
</block>
<block>
<key>DoA_BladeRF_sample_offset</key>
<param><key>id</key><value>DoA_BladeRF_sample_offset_0</value></param>
<param><key>num_xcorr</key><value>5</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vector_len</key><value>40960</value></param>
</block>
<block>
<key>DoA_BladeRF_vector_steering</key>
<param><key>id</key><value>DoA_BladeRF_vector_steering_0</value></param>
<param><key>arg</key><value>0.0</value></param>
<param><key>comment</key><value>Vector dap ung mang</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>angle</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_fm_demod_cf</key>
<param><key>id</key><value>analog_fm_demod_cf_0</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>10e3</value></param>
<param><key>audio_stop</key><value>11e3</value></param>
<param><key>chan_rate</key><value>samp_rate / 3</value></param>
<param><key>deviation</key><value>10e3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>tau</key><value>0</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>100</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0_0</value></param>
<param><key>amp</key><value>0.2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>100</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>0.2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>100e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>1e3</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>comment</key><value>Song mang</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_CONST_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_CONST_WAVE</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ok_to_block</key><value>False</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>decim</key><value>3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>140e3</value></param>
<param><key>low_cutoff_freq</key><value>100e3</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>2e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_argmax_xx</key>
<param><key>id</key><value>blocks_argmax_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>num_item</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>1000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1</value></param>
<param><key>file</key><value>/home/haison98/gr-DoA_BladeRF/972134.ts</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_integrate_xx</key>
<param><key>id</key><value>blocks_integrate_xx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>n</key><value>500</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1_0</value></param>
<param><key>n</key><value>500</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>-choose  -1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_1</value></param>
<param><key>const</key><value>0.5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>vol</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0</value></param>
<param><key>const</key><value>not choose</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_1</value></param>
<param><key>const</key><value>not choose</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2_1</value></param>
<param><key>const</key><value>1.0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_3_0_0</value></param>
<param><key>const</key><value>choose</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_3_1</value></param>
<param><key>const</key><value>choose</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_x_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_short_to_float</key>
<param><key>id</key><value>blocks_short_to_float_0</value></param>
<param><key>scale</key><value>int(num_item / 181)</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>num_item</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>10</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>num_item</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>10</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>40960</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>40960</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>100</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sensitivity</key><value>753982.2369</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/haison98/sdr-examples/multi_tx.wav</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0_0_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0</value></param>
<param><key>noise_voltage</key><value>0.1</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0_1</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0</value></param>
<param><key>noise_voltage</key><value>0.1</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>channels_fading_model</key>
<param><key>id</key><value>channels_fading_model_0_0_0</value></param>
<param><key>LOS</key><value>False</value></param>
<param><key>fDTs</key><value>10.0/samp_rate</value></param>
<param><key>N</key><value>8</value></param>
<param><key>seed</key><value>1000</value></param>
</block>
<block>
<key>channels_fading_model</key>
<param><key>id</key><value>channels_fading_model_0_1</value></param>
<param><key>LOS</key><value>False</value></param>
<param><key>fDTs</key><value>10.0/samp_rate</value></param>
<param><key>N</key><value>8</value></param>
<param><key>seed</key><value>1000</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>delay_sample</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>digital_ofdm_cyclic_prefixer</key>
<param><key>id</key><value>digital_ofdm_cyclic_prefixer_0</value></param>
<param><key>cp_len</key><value>256</value></param>
<param><key>input_size</key><value>32768</value></param>
<param><key>tagname</key><value></value></param>
</block>
<block>
<key>doa_unwrap_ff</key>
<param><key>id</key><value>doa_unwrap_ff_0_0</value></param>
<param><key>max</key><value>3.14159265</value></param>
<param><key>min</key><value>-3.14159265</value></param>
<param><key>vector_size</key><value>100</value></param>
</block>
<block>
<key>doa_variance_ff</key>
<param><key>id</key><value>doa_variance_ff_0</value></param>
<param><key>vec_len</key><value>100</value></param>
</block>
<block>
<key>dtv_dvb_bbheader_bb</key>
<param><key>id</key><value>dtv_dvb_bbheader_bb_0</value></param>
<param><key>mode</key><value>INPUTMODE_HIEFF</value></param>
<param><key>rate1</key><value>C3_4</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>inband</key><value>INBAND_OFF</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvb_bbscrambler_bb</key>
<param><key>id</key><value>dtv_dvb_bbscrambler_bb_0</value></param>
<param><key>rate1</key><value>C3_4</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvb_bch_bb</key>
<param><key>id</key><value>dtv_dvb_bch_bb_0</value></param>
<param><key>rate1</key><value>C3_4</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvb_ldpc_bb</key>
<param><key>id</key><value>dtv_dvb_ldpc_bb_0</value></param>
<param><key>rate1</key><value>C2_3</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>standard</key><value>STANDARD_DVBT2</value></param>
</block>
<block>
<key>dtv_dvbt2_cellinterleaver_cc</key>
<param><key>id</key><value>dtv_dvbt2_cellinterleaver_cc_0</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>fecblocks</key><value>200</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>tiblocks</key><value>3</value></param>
</block>
<block>
<key>dtv_dvbt2_framemapper_cc</key>
<param><key>id</key><value>dtv_dvbt2_framemapper_cc_0</value></param>
<param><key>rate</key><value>C3_4</value></param>
<param><key>rotation</key><value>ROTATION_ON</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fecblocks</key><value>200</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
<param><key>fftsize1</key><value>FFTSIZE_32K_T2GI</value></param>
<param><key>guardinterval</key><value>GI_1_128</value></param>
<param><key>l1constellation</key><value>L1_MOD_64QAM</value></param>
<param><key>numdatasyms</key><value>59</value></param>
<param><key>paprmode1</key><value>PAPR_TR</value></param>
<param><key>pilotpattern</key><value>PILOT_PP7</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>version</key><value>VERSION_111</value></param>
<param><key>t2frames</key><value>2</value></param>
<param><key>tiblocks</key><value>3</value></param>
</block>
<block>
<key>dtv_dvbt2_freqinterleaver_cc</key>
<param><key>id</key><value>dtv_dvbt2_freqinterleaver_cc_0</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize</key><value>FFTSIZE_32K_T2GI</value></param>
<param><key>guardinterval</key><value>GI_1_128</value></param>
<param><key>numdatasyms</key><value>59</value></param>
<param><key>paprmode1</key><value>PAPR_TR</value></param>
<param><key>pilotpattern</key><value>PILOT_PP7</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>version</key><value>VERSION_111</value></param>
</block>
<block>
<key>dtv_dvbt2_interleaver_bb</key>
<param><key>id</key><value>dtv_dvbt2_interleaver_bb_0</value></param>
<param><key>rate</key><value>C3_4</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
</block>
<block>
<key>dtv_dvbt2_modulator_bc</key>
<param><key>id</key><value>dtv_dvbt2_modulator_bc_0</value></param>
<param><key>rotation</key><value>ROTATION_ON</value></param>
<param><key>constellation</key><value>MOD_256QAM</value></param>
<param><key>framesize</key><value>FECFRAME_NORMAL</value></param>
</block>
<block>
<key>dtv_dvbt2_p1insertion_cc</key>
<param><key>id</key><value>dtv_dvbt2_p1insertion_cc_0</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize1</key><value>FFTSIZE_32K_T2GI</value></param>
<param><key>guardinterval</key><value>GI_1_128</value></param>
<param><key>numdatasyms</key><value>59</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>showlevels</key><value>SHOWLEVELS_ON</value></param>
<param><key>version</key><value>VERSION_111</value></param>
<param><key>vclip</key><value>3.31</value></param>
</block>
<block>
<key>dtv_dvbt2_paprtr_cc</key>
<param><key>id</key><value>dtv_dvbt2_paprtr_cc_0</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize</key><value>FFTSIZE_32K_T2GI</value></param>
<param><key>guardinterval</key><value>GI_1_128</value></param>
<param><key>iterations</key><value>10</value></param>
<param><key>numdatasyms</key><value>59</value></param>
<param><key>paprmode1</key><value>PAPR_TR</value></param>
<param><key>pilotpattern</key><value>PILOT_PP7</value></param>
<param><key>version</key><value>VERSION_111</value></param>
<param><key>vclip</key><value>3.3</value></param>
</block>
<block>
<key>dtv_dvbt2_pilotgenerator_cc</key>
<param><key>id</key><value>dtv_dvbt2_pilotgenerator_cc_0</value></param>
<param><key>bandwidth</key><value>BANDWIDTH_1_7_MHZ</value></param>
<param><key>carriermode</key><value>CARRIERS_EXTENDED</value></param>
<param><key>fftsize</key><value>FFTSIZE_32K_T2GI</value></param>
<param><key>guardinterval</key><value>GI_1_128</value></param>
<param><key>numdatasyms</key><value>59</value></param>
<param><key>paprmode1</key><value>PAPR_TR</value></param>
<param><key>pilotpattern</key><value>PILOT_PP7</value></param>
<param><key>preamble1</key><value>PREAMBLE_T2_SISO</value></param>
<param><key>equalization</key><value>EQUALIZATION_ON</value></param>
<param><key>version</key><value>VERSION_111</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>my_block_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>FM Signal</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>note</key><value>Giai dieu che</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe65</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate / 3</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tab@2</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"Pho tin hieu giai dieu che"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tab@0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>name</key><value>"Pho tin hieu thu"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value>Bien do</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>tab@1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>"Direction of Arrival"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>num_item</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0 / (int(num_item/181))</value></param>
<param><key>x_units</key><value>"do"</value></param>
<param><key>ymax</key><value>20</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>15</value></param>
<param><key>taps</key><value>taps_up</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>2</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab</value></param>
<param><key>label0</key><value>Sync</value></param>
<param><key>label1</key><value>DoA</value></param>
<param><key>label2</key><value>Demod</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>capon</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>comment</key><value>Tin hieu mo phong 2</value></param>
<param><key>stream_id</key><value>2</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>comment</key><value>Tin hieu mo phong 1</value></param>
<param><key>stream_id</key><value>1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>comment</key><value>Tin hieu da them phase offset</value></param>
<param><key>stream_id</key><value>1_SDR</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1_0</value></param>
<param><key>comment</key><value>Tin hieu da them Delay</value></param>
<param><key>stream_id</key><value>2_SDR</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>demod</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>1_synced</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>2_synced</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>2_SDR</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>1_SDR</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0</value></param>
<param><key>comment</key><value>Tin hieu da dong bo 1</value></param>
<param><key>stream_id</key><value>1_synced</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_1</value></param>
<param><key>comment</key><value>Tin hieu da dong bo 2</value></param>
<param><key>stream_id</key><value>2_synced</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>capon</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>demod</value></param>
</block>
<connection><source_block_id>DoA_BladeRF_DOApy_0</source_block_id><sink_block_id>blocks_argmax_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DoA_BladeRF_DOApy_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DoA_BladeRF_Delay_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DoA_BladeRF_Delay_1</source_block_id><sink_block_id>DoA_BladeRF_multi_exp_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DoA_BladeRF_Hold_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DoA_BladeRF_PCA_0</source_block_id><sink_block_id>DoA_BladeRF_Hold_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DoA_BladeRF_PCA_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DoA_BladeRF_mess_sink_f_0</source_block_id><sink_block_id>DoA_BladeRF_vector_steering_0</sink_block_id><source_key>out</source_key><sink_key>arg</sink_key></connection>
<connection><source_block_id>DoA_BladeRF_mess_sink_f_1</source_block_id><sink_block_id>DoA_BladeRF_multi_exp_1</sink_block_id><source_key>out</source_key><sink_key>arg</sink_key></connection>
<connection><source_block_id>DoA_BladeRF_multi_exp_0</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DoA_BladeRF_multi_exp_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DoA_BladeRF_multi_exp_1</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DoA_BladeRF_multi_exp_1</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DoA_BladeRF_sample_offset_0</source_block_id><sink_block_id>delay_sample</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>DoA_BladeRF_vector_steering_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>DoA_BladeRF_mess_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fm_demod_cf_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_1</source_block_id><sink_block_id>blocks_multiply_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>analog_fm_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_integrate_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_0</source_block_id><sink_block_id>DoA_BladeRF_vector_steering_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_0_0</source_block_id><sink_block_id>DoA_BladeRF_multi_exp_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_1</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>blocks_short_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_stream_to_vector_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>virtual_sink_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_1</source_block_id><sink_block_id>dtv_dvb_bbheader_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_integrate_xx_0</source_block_id><sink_block_id>blocks_vco_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>channels_channel_model_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>channels_channel_model_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>DoA_BladeRF_mess_sink_f_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>my_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>analog_sig_source_x_0_0</sink_block_id><source_key>0</source_key><sink_key>freq</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_1</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>blocks_add_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2_1</source_block_id><sink_block_id>blocks_multiply_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_3_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_3_1</source_block_id><sink_block_id>blocks_add_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0_0</source_block_id><sink_block_id>channels_channel_model_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_1</source_block_id><sink_block_id>channels_channel_model_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_short_to_float_0</source_block_id><sink_block_id>blocks_probe_signal_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>DoA_BladeRF_DOApy_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_0</source_block_id><sink_block_id>DoA_BladeRF_PCA_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0_1</source_block_id><sink_block_id>DoA_BladeRF_DOApy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_1</source_block_id><sink_block_id>DoA_BladeRF_PCA_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1</source_block_id><sink_block_id>DoA_BladeRF_sample_offset_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1_0</source_block_id><sink_block_id>DoA_BladeRF_sample_offset_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_2_0</source_block_id><sink_block_id>doa_unwrap_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>DoA_BladeRF_vector_steering_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>channels_channel_model_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>channels_channel_model_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>virtual_sink_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0_0_0</source_block_id><sink_block_id>channels_fading_model_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_channel_model_0_1</source_block_id><sink_block_id>channels_fading_model_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_fading_model_0_0_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_fading_model_0_1</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_ofdm_cyclic_prefixer_0</source_block_id><sink_block_id>dtv_dvbt2_p1insertion_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_unwrap_ff_0_0</source_block_id><sink_block_id>doa_variance_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doa_variance_ff_0</source_block_id><sink_block_id>probe65</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bbheader_bb_0</source_block_id><sink_block_id>dtv_dvb_bbscrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bbscrambler_bb_0</source_block_id><sink_block_id>dtv_dvb_bch_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bch_bb_0</source_block_id><sink_block_id>dtv_dvb_ldpc_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_ldpc_bb_0</source_block_id><sink_block_id>dtv_dvbt2_interleaver_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_cellinterleaver_cc_0</source_block_id><sink_block_id>dtv_dvbt2_framemapper_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_framemapper_cc_0</source_block_id><sink_block_id>dtv_dvbt2_freqinterleaver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_freqinterleaver_cc_0</source_block_id><sink_block_id>dtv_dvbt2_pilotgenerator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_interleaver_bb_0</source_block_id><sink_block_id>dtv_dvbt2_modulator_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_modulator_bc_0</source_block_id><sink_block_id>dtv_dvbt2_cellinterleaver_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_p1insertion_cc_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_paprtr_cc_0</source_block_id><sink_block_id>digital_ofdm_cyclic_prefixer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbt2_pilotgenerator_cc_0</source_block_id><sink_block_id>dtv_dvbt2_paprtr_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>DoA_BladeRF_multi_exp_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_3_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>DoA_BladeRF_Delay_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>DoA_BladeRF_Delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_3_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>blocks_stream_to_vector_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
